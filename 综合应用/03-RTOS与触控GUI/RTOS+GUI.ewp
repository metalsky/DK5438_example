# IAR project RTOS+GUI.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 500
  General.GHeapSize2: 200
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: OS_LIBMODE_D
  ICC430.newCCIncludePaths: $TOOLKIT_DIR$\PowerPac\RTOS\INC\
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: CLOCK.C DS18B20.C enc28j60.c GUI.C ip_arp_udp.c KEY.C LED.C main.c netcomm.c RTCASMFunctions_IAR.s43 TFTDRV.C timeout.c touch.c
  group LIB
    Lib/: rtos430xsf_D.r43
  group SETUP
    Setup/: BSP.c OS_Error.c Rtosinit_XMS430F5438 101023.c
