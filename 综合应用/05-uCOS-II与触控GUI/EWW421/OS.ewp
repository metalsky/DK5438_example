# IAR project OS.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 128
  General.GHeapSize2: 128
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: APP\; BSP\; BSP\BW-DK5438 HAL; uC-CPU; uC-LIB; uCOS-II
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: APP\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group App
    App/: app.c app_hooks.c CLOCK.C cpu_cfg.h cstartup.s43 GUI.C includes.h io430x54x.h msp430.h msp430x54x.H
  group BSP
    BSP/: bsp.c bsp.h
  group BSP/BW-DK5438 HAL
    BSP/BW-DK5438 HAL/: cc2500.h DS18B20.C enc28j60.c hal_adc.c hal_adc.h hal_board.c hal_board.h hal_buttons.c hal_buttons.h hal_lcd.c hal_lcd.h hal_lcd_fonts.h hal_MSP-EXP430F5438.h hal_rf.c hal_rf.h hal_usb.h ip_arp_udp.c KEY.C LED.C RTCASMFunctions_IAR.s43 TFTDRV.C touch.c
  group Cfg
    App/: app_cfg.h os_cfg.h
  group uC/CPU
    uC-CPU/: cpu.h cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-II
    uCOS-II/: os_core.c os_cpu.h os_cpu_a.s43 os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
