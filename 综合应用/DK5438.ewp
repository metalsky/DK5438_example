# IAR project DK5438.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 580
  General.GHeapSize2: 380
  General.RadioHeapSizeType: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: D:\桌面临时\MSP430F5418开发板\程序\源代码\lnk430F5418Update.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    源代码/: Init.c Main.c Menu_Res.h Timer.c Usart.c
    ./: RTCASMFunctions_IAR.s43
    $EW_DIR$/430/inc/clib/: string.h
